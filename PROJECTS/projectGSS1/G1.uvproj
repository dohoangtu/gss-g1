# Keil uVision project G1.uvproj, settings and files
target G1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: G1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\projectGSS1;..\..\LIB\CMSIS\Include;..\..\LIB\CMSIS\ST\STM32F4xx\Include;..\..\LIB\STM32F4xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\LIB\G_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4_Discovery
    ../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group MDK_ARM
    ../../LIB/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Gremsy_LIB
    ../../LIB/G_LIB/: gADC.c gControlMotor.c gDelay.c gEXTI.c gGPIO.c gPID.c gTIM.c gUSART.c gLCD.c
